<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_block</value></param>
<param><key>author</key><value>André Gomes</value></param>
<param><key>category</key><value>[MAC Protocols Aux]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Carrier Sense</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>samples</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>samples</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>debug_mode</value></param>
<param><key>comment</key><value>If 0, debug mode turned off;
if 1, debug mode turned on.</value></param>
<param><key>label</key><value>Debug mode</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>samples</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(samples)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_disc</value></param>
<param><key>label</key><value>Gain discount</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>macprotocols_cs</key>
<param><key>id</key><value>macprotocols_cs_0</value></param>
<param><key>debug</key><value>debug_mode</value></param>
<param><key>gain</key><value>gain_disc</value></param>
<param><key>num_samples</key><value>samples</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samples</value></param>
<param><key>label</key><value>Number of samples FFT</value></param>
<param><key>value</key><value>64</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>macprotocols_cs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>macprotocols_cs_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out_csense</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>macprotocols_cs_0</sink_block_id><source_key>out</source_key><sink_key>in_control</sink_key></connection>
</flow_graph>
