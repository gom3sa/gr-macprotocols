<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>my_cs</value></param>
<param><key>author</key><value>André Gomes</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>Input: 

1) Signal source as IQ data;
2) Control message. Format: "threshold=&lt;dbm&gt;,time=&lt;microseconds&gt;"

Output:

1) Medium sensing result: BUSY or IDDLE</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Hier Carrier Sense</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>samples</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>samples</value></param>
</block>
<block>
<key>carriersense_cs</key>
<param><key>id</key><value>carriersense_cs_0</value></param>
<param><key>gain</key><value>gain_disc</value></param>
<param><key>num_samples</key><value>samples</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cut_freq</value></param>
<param><key>label</key><value>Cutoff frequency</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>samples</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>2</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(samples)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_disc</value></param>
<param><key>label</key><value>Gain discount</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>cut_freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>8*cut_freq</value></param>
<param><key>width</key><value>500e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samples</value></param>
<param><key>label</key><value>Number of samples FFT</value></param>
<param><key>value</key><value>256</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>carriersense_cs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carriersense_cs_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out_csense</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>carriersense_cs_0</sink_block_id><source_key>out</source_key><sink_key>in_control</sink_key></connection>
</flow_graph>
