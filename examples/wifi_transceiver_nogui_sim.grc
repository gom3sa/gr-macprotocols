<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_transceiver_1</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoding</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>5.89e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interval</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mac_addr1</value></param>
<param><key>value</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mac_addr2</value></param>
<param><key>value</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>750e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>750e-3</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/tmp/wifi.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/tmp/wifi.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/tmp/wifi.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/tmp/wifi.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("".join("a" for i in range(pdu_length)))</value></param>
<param><key>period</key><value>interval</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
<param><key>pad_front</key><value>10000</value></param>
<param><key>pad_tail</key><value>10000</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
<param><key>pad_front</key><value>10000</value></param>
<param><key>pad_tail</key><value>10000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
</block>
<block>
<key>hier_block</key>
<param><key>id</key><value>hier_block_0</value></param>
<param><key>debug_mode</key><value>1</value></param>
<param><key>gain_disc</key><value>30</value></param>
<param><key>samples</key><value>64</value></param>
</block>
<block>
<key>hier_block</key>
<param><key>id</key><value>hier_block_0_0</value></param>
<param><key>debug_mode</key><value>1</value></param>
<param><key>gain_disc</key><value>30</value></param>
<param><key>samples</key><value>64</value></param>
</block>
<block>
<key>ieee802_11_mac</key>
<param><key>id</key><value>ieee802_11_mac_0_0</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 255]</value></param>
<param><key>dst_mac</key><value>mac_addr2</value></param>
<param><key>maxoutbuf</key><value>4096</value></param>
<param><key>minoutbuf</key><value>256</value></param>
<param><key>src_mac</key><value>mac_addr1</value></param>
</block>
<block>
<key>ieee802_11_mac</key>
<param><key>id</key><value>ieee802_11_mac_0_0_0</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 255]</value></param>
<param><key>dst_mac</key><value>mac_addr1</value></param>
<param><key>maxoutbuf</key><value>4096</value></param>
<param><key>minoutbuf</key><value>256</value></param>
<param><key>src_mac</key><value>mac_addr2</value></param>
</block>
<block>
<key>ieee802_11_parse_mac</key>
<param><key>id</key><value>ieee802_11_parse_mac_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_parse_mac</key>
<param><key>id</key><value>ieee802_11_parse_mac_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>macprotocols_csma_ca</key>
<param><key>id</key><value>macprotocols_csma_ca_0</value></param>
<param><key>alpha</key><value>50000</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>difs</key><value>34</value></param>
<param><key>src_mac</key><value>mac_addr1</value></param>
<param><key>sifs</key><value>16</value></param>
<param><key>slot_time</key><value>9</value></param>
</block>
<block>
<key>macprotocols_csma_ca</key>
<param><key>id</key><value>macprotocols_csma_ca_0_0</value></param>
<param><key>alpha</key><value>50000</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>difs</key><value>34</value></param>
<param><key>src_mac</key><value>mac_addr2</value></param>
<param><key>sifs</key><value>16</value></param>
<param><key>slot_time</key><value>9</value></param>
</block>
<block>
<key>macprotocols_frame_buffer</key>
<param><key>id</key><value>macprotocols_frame_buffer_0</value></param>
<param><key>buff_size</key><value>256</value></param>
</block>
<block>
<key>macprotocols_frame_buffer</key>
<param><key>id</key><value>macprotocols_frame_buffer_0_0</value></param>
<param><key>buff_size</key><value>256</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>sensitivity</key><value>0.56</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0_0</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>sensitivity</key><value>0.56</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>ieee802_11_mac_0_0</sink_block_id><source_key>strobe</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>foo_packet_pad2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>foo_packet_pad2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>ieee802_11_mac_0_0</sink_block_id><source_key>pdus</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>hier_block_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>wifi_phy_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0_0</source_block_id><sink_block_id>hier_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0_1</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_block_0</source_block_id><sink_block_id>macprotocols_csma_ca_0</sink_block_id><source_key>out</source_key><sink_key>cs in</sink_key></connection>
<connection><source_block_id>hier_block_0_0</source_block_id><sink_block_id>macprotocols_csma_ca_0_0</sink_block_id><source_key>out</source_key><sink_key>cs in</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0_0</source_block_id><sink_block_id>foo_wireshark_connector_0_0</sink_block_id><source_key>app out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0</sink_block_id><source_key>phy out</source_key><sink_key>frame in</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0_0_0</source_block_id><sink_block_id>foo_wireshark_connector_0_0_0</sink_block_id><source_key>app out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_mac_0_0_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0_0</sink_block_id><source_key>phy out</source_key><sink_key>frame in</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0</sink_block_id><source_key>frame request</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>frame to phy</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0</source_block_id><sink_block_id>hier_block_0</sink_block_id><source_key>request to cs</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0_0</source_block_id><sink_block_id>macprotocols_frame_buffer_0_0</sink_block_id><source_key>frame request</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0_0</source_block_id><sink_block_id>wifi_phy_hier_0_0</sink_block_id><source_key>frame to phy</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>macprotocols_csma_ca_0_0</source_block_id><sink_block_id>hier_block_0_0</sink_block_id><source_key>request to cs</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>macprotocols_frame_buffer_0</source_block_id><sink_block_id>macprotocols_csma_ca_0</sink_block_id><source_key>frame out</source_key><sink_key>frame from buffer</sink_key></connection>
<connection><source_block_id>macprotocols_frame_buffer_0_0</source_block_id><sink_block_id>macprotocols_csma_ca_0_0</sink_block_id><source_key>frame out</source_key><sink_key>frame from buffer</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_parse_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>macprotocols_csma_ca_0</sink_block_id><source_key>mac_out</source_key><sink_key>frame from phy</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>foo_wireshark_connector_0_1</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>ieee802_11_parse_mac_0_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>macprotocols_csma_ca_0_0</sink_block_id><source_key>mac_out</source_key><sink_key>frame from phy</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
